# Keil uVision project test.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: PY32F403xD Puya
  pack: Puya.PY32F4xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00060000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=3 wLevel=3
  c define: PY32F403xD,HSE_VALUE=16000000ul,USE_FULL_LL_DRIVER,__TARGET_FPU_VFP
  c include: .\PY32F403_HAL_Driver\Inc;.\Src;.\FreeRTOS-Kernel\include;.\FreeRTOS-Kernel;.\ff15a\source;.\InfoNES\src;.\LiteNES;.\nes
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Src
    ./Src/: fifo.c fifo.h main.c py32f403_hal_conf.h py32f403_it.c py32f403_it.h startup_py32f403xx.s system_py32f403.c uart.c uart.h shell.c shell.h shell_func.c shell_func.h xprintf.c xprintf.h spi.c spi.h flash.c flash.h flash_itf.c flash_itf.h global.h md5.c md5.h xmodem.c xmodem.h ymodem.c ymodem.h st7789.c st7789.h st7789_itf.c st7789_itf.h st7789_test.c st7789_test.h psram.c psram.h
  group Driver
    ./PY32F403_HAL_Driver/Src/: py32f403_hal.c py32f403_hal_adc.c py32f403_hal_adc_ex.c py32f403_hal_canfd.c py32f403_hal_cortex.c py32f403_hal_crc.c py32f403_hal_ctc.c py32f403_hal_dma.c py32f403_hal_esmc.c py32f403_hal_exti.c py32f403_hal_flash.c py32f403_hal_gpio.c py32f403_hal_i2c.c py32f403_hal_i2s.c py32f403_hal_irda.c py32f403_hal_iwdg.c py32f403_hal_pwr.c py32f403_hal_pwr_ex.c py32f403_hal_rcc.c py32f403_hal_rcc_ex.c py32f403_hal_rtc.c py32f403_hal_rtc_ex.c py32f403_hal_sd.c py32f403_hal_smartcard.c py32f403_hal_spi.c py32f403_hal_spi_ex.c py32f403_hal_tim.c py32f403_hal_tim_ex.c py32f403_hal_uart.c py32f403_hal_usart.c py32f403_hal_wwdg.c py32f403_ll_sdmmc.c py32f403_ll_adc.c py32f403_ll_crc.c py32f403_ll_ctc.c py32f403_ll_dma.c py32f403_ll_exti.c py32f403_ll_gpio.c py32f403_ll_i2c.c py32f403_ll_pwr.c py32f403_ll_rcc.c py32f403_ll_rtc.c py32f403_ll_spi.c py32f403_ll_tim.c py32f403_ll_usart.c py32f403_ll_utils.c
    ./PY32F403_HAL_Driver/Inc/: py32f4xx_hal.h py32f403_hal_adc.h py32f403_hal_adc_ex.h py32f403_hal_canfd.h py32f403_hal_cortex.h py32f403_hal_crc.h py32f403_hal_ctc.h py32f403_hal_def.h py32f403_hal_dma.h py32f403_hal_dma_ex.h py32f403_hal_esmc.h py32f403_hal_exti.h py32f403_hal_flash.h py32f403_hal_gpio.h py32f403_hal_gpio_ex.h py32f403_hal_i2c.h py32f403_hal_i2s.h py32f403_hal_irda.h py32f403_hal_iwdg.h py32f403_hal_pwr.h py32f403_hal_pwr_ex.h py32f403_hal_rcc.h py32f403_hal_rcc_ex.h py32f403_hal_rtc.h py32f403_hal_rtc_ex.h py32f403_hal_sd.h py32f403_hal_smartcard.h py32f403_hal_spi.h py32f403_hal_spi_ex.h py32f403_hal_tim.h py32f403_hal_tim_ex.h py32f403_hal_uart.h py32f403_hal_usart.h py32f403_hal_wwdg.h py32f403_ll_sdmmc.h py32f403_ll_adc.h py32f403_ll_bus.h py32f403_ll_cortex.h py32f403_ll_crc.h py32f403_ll_ctc.h py32f403_ll_dma.h py32f403_ll_exti.h py32f403_ll_flash.h py32f403_ll_gpio.h py32f403_ll_i2c.h py32f403_ll_iwdg.h py32f403_ll_pwr.h py32f403_ll_rcc.h py32f403_ll_rtc.h py32f403_ll_spi.h py32f403_ll_system.h py32f403_ll_tim.h py32f403_ll_usart.h py32f403_ll_utils.h py32f403_ll_wwdg.h
  group FreeRTOS
    ./FreeRTOS-Kernel/: croutine.c event_groups.c FreeRTOSConfig.h heap_4.c list.c port.c portmacro.h queue.c stream_buffer.c tasks.c timers.c
  group fatfs
    ./ff15a/source/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
  group nessrc
    ./NES/: 6502.s cart.s nes_apu.c nes_main.c nes_mapper.c nes_ppu.c
software components: CMSIS:CORE 6.1.0
